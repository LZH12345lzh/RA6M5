# Keil uVision project EBF_RA6M5.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA6M5BH Renesas
  pack: Renesas.RA_DFP.4.4.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: EBF_RA6M5
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.0.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src;.\user\Bsp;.\user\FreeRTOS\include;.\user\FreeRTOS\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;.\user\FreeRTOS\portable\ARMv8M\non_secure;.\user\FreeRTOS;.\user\APP;.\user\FATFS;.\user\qe_gen;.\ra\fsp\src\bsp\cmsis\Device\RENESAS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group Bsp
    ./user/Bsp/: bsp_key.c bsp_led.c bsp_SysTick.c bsp_uart4.c i2c_ee.c bsp_qspi_flash.c bsp_sdhi.c bsp_adc.c bsp_dac.c bsp_gpt_timing.c bsp_gpt_input_capture.c bsp_gpt_pwm_output.c bsp_iwdt.c
  group FreeRTOS
    ./user/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./user/FreeRTOS/portable/MemMang/: heap_4.c
    ./user/FreeRTOS/portable/ARMv8M/non_secure/: port.c
    ./user/FreeRTOS/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c
  group App
    ./user/APP/: Key_Task.c Led_Task.c Debug_Task.c Fatfs_Task.c Adc_Task.c Pwm_Task.c Systick_Task.c Wdt_Task.c
  group Fatfs
    ./user/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Qe_gen
    ./user/qe_gen/: qe_touch_config.c qe_touch_sample.c
software components: Flex Software:RA Configuration 1.0.0
